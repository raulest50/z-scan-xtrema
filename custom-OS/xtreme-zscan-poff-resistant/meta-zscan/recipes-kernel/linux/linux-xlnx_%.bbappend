FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append:amd-cortexa53-mali-common = " file://zscan.cfg"
